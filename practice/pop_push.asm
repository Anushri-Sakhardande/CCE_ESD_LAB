	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=NUM
	LDR R1,[R0]
	MOV R3,#32
LOOP
	LSRS R1,#1
	ADC R7,#0
	AND R8,R7,#0x0F
	CMP R8,#0x0A
	BLO DOWN
	SUB R7,#0xA
	ADD R7,#0x10
DOWN 
	SUBS R3,#1
	BNE LOOP
STOP B STOP
NUM DCD 0xFFFFFFFF
	AREA mydata,DATA,READWRITE
RESULT DCD  0
	END
